# Keil uVision project servo_control_system.uvprojx, settings and files
target servo_control_system (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: servo_control_system
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c misc: --C99
  c include: ../Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                               ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
    ../Src/main/: loop_main.c interrupt.c motor.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_i2c_ex.c
  group AW9106B_LED
    ../Src/main/: left_breaking.c right_breaking.c front_breaking.c
  group WTC7514DSI
    ../Src/main/: DEMO_IIC_7514.C
software components: CMSIS:CORE 4.1.0
